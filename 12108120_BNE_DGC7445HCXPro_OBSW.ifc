Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable], RevitIdentifiers [VersionGUID: 0f3d74a6-0bd6-45f6-8792-bfb240975b7f, NumberOfSaves: 1]
File name: 0001
Time: 2024-08-14T12:51:28+01:00
Written by: ODA SDAI 23.12
Made in: Autodesk Revit 24.0.20.20 (ENU) - IFC 24.0.20.20

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 12108120_BNE_DGC7445HCXPro_OBSW:23744568_BNE_12108120_DGC7445HCXPro_OBSW, (2)
In: Default
Type - Material: z_Miele_Design_Zinc_Steel, z_Miele_Connection_Water_IN, z_Miele_Connection_Water_OUT, z_Miele_Connection_Electric, z_Miele_Design_Steel_Chrom, z_Miele_Design_OBSW, <Unnamed>
Type - Pset_ManufacturerTypeInformation - Manufacturer: Miele
Type - Pset_ProductRequirements - Category: Specialty Equipment
Type - Pset_ProvisionForVoid - Width: 595 mm; Height: 456 mm; Depth: 569 mm
Classification: E1090320 Uniformat (Uniformat)
Pset_BuildingElementProxyCommon - Reference: 23744568_BNE_12108120_DGC7445HCXPro_OBSW; sets with these values: 2

# IfcDistributionPort, Port_353708_1
Description: Flow; FlowDirection: SOURCEANDSINK
